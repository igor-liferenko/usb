# IAR project EVK527-ATMega32U4-usbdevice_cdc.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDiagSuppress: Pe111,Pe550
  ICCAVR.newCCIncludePaths: ..; ../conf; ../../../
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm32u4.xcl
configuration Release (AVR)
  as the first configuration, except:
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../: cdc_task.c main.c uart_usb_lib.c usb_descriptors.c usb_specific_request.c
    ../../../lib_mcu/flash/: flash_drv.s90
    ../../../lib_mcu/power/: power_drv.c
    ../../../modules/scheduler/: scheduler.c
    ../../../lib_mcu/util/: start_boot.c
    ../../../lib_mcu/uart/: uart_lib.c
    ../../../modules/usb/device_chap9/: usb_device_task.c usb_standard_request.c
    ../../../lib_mcu/usb/: usb_drv.c
    ../../../modules/usb/: usb_task.c
